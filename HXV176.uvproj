# Keil uVision project HXV176.uvproj, settings and files
target HXOS_V176 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HXV176 +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: .\HXOS\include;.\HXOS\lib;.\HXOS\arch\stm32;C:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\INC\ST\STM32F10x;.\HXOS\network;.\HXOS\drivers\stm32;.\Startup\STM32F10x_lib\inc;.
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HXOS
    ./HXOS/arch/stm32/: ARCH.H arch_stm.c HELLOCN.C osadapt.S syn_mech.h system_stm32f10x.c
    ./HXOS/config/: config.h
    ./HXOS/kernel/: COMQUEUE.C console.c DEVMGR.C DIM.C HEAP.C IOMGR.C IOMGR2.C KAPI.C KERMOD.C KMEMMGR.C KTMGR.C KTMGR2.C MEM_FBL.C MEMMGR.C MODMGR.C OBJMGR.C OBJQUEUE.C PAGEIDX.C PCI_DRV.C PERF.C STATCPU.C SYNOBJ.C SYSCALL.C SYSTEM.C TYPES.C VMM.C synobj2.c CharDisplay.C
    ./HXOS/kthread/: idle.c
    ./HXOS/lib/: stdio.c stdio.h string.c string.h sysmem.c atox.c
    ./HXOS/osentry/: DRVENTRY.C mem_scat.c OS_ENTRY.C
    ./HXOS/shell/: EXTCMD.C EXTCMD.H SHELL.C SHELL.H SHELL1.C FDISK2.C FDISK.C FIBONACCI.C FS.C HEDIT.C HYPERTRM.C IOCTRL_S.C network2.c network.c STAT_S.C SYSD_S.C SHELL_HELP_SMT32.C HISCMD .C
    ./HXOS/network/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./HXOS/network/arch/: sys_arch.c
    ./HXOS/network/core/: autoip.c def.c dhcp.c dns.c icmp.c igmp.c inet.c inet_chksum.c init.c ip.c ip_addr.c ip_frag.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./HXOS/network/netif/: slipif.c etharp.c
    ./HXOS/include/: lwipopts.h console.h
    ./HXOS/drivers/stm32/: usart.h
    ./HXOS/network/ethernet/: ethentry.c ethif.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
    ./Startup/STM32F10x_lib/: STM32F10xR.LIB
  group User
    ./User/: usermain.c ledctrl.c
  group Device
    ./HXOS/drivers/stm32/led/: led.c
    ./HXOS/drivers/stm32/usart/: usart.c
    ./HXOS/drivers/stm32/enc_eth/: enc28j60.c Ethernet.c spi.c
  group WLAN
    ./HXOS/drivers/stm32/mrvlwifi/: 11d.c 8686.c assoc.c cmd.c common.c core.c help.c help_firmware.c if_sdio.c marvel_main.c marvel8385_firmware.c marvelif.c marvell_ops.c rx.c s3cmci.c scan.c sdio.c sdio_cis.c sdio_drv.c stm32sys.c
